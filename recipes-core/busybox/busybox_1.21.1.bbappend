FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://sid.cfg \
	    file://cttyhack.cfg"
